# Keil uVision project hongjingbei.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: hongjingbei +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hongjing_lib;.\hongjing_lib\inc
  group src
    ./hongjing_lib/src/: delay.c MPU6050.c Uart.c jiexi.c
  group inc
    ./hongjing_lib/inc/: Config.h delay.h MPU6050.h oled.h timer.h Uart.h gprs.h
  group usr
    ./: hongjingbei.c
