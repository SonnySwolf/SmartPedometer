# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib\inc;..\STC15W4K58S4
  group Source Group 1
    ./: project.c
  group src
    ./lib/src/: delay.c Uart.c MPU6050.c
  group inc
    ./lib/inc/: delay.h Uart.h Config.h MPU6050.h
